# Keil uVision project Comitas_hackathon_STM32F100RB.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Comitas_hackathon_STM32F100RB
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Src
    ./: main.c common.c ds18b20.c TH02.c SPI_for_BME.c UART.c
  group Inc
    ./: common.h ds18b20.h TH02.h SPI_for_BME.h UART.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
